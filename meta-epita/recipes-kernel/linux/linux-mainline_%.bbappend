# Capteur BME280

FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-dts-add-BME280-on-i2c0.patch"
SRC_URI += "file://bme280.cfg"